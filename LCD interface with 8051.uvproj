# Keil uVision project LCD interface with 8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: LCD interface DS3231 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd.h lcd.c rtc.h inputoutput.h i2c.h i2c.c header.h external.h DS3231RTC.c
